# Keil uVision project LpxTesterSite_v3.uvprojx, settings and files
target LpxTesterSite_v3 (6110000::V6.11::.\ARMCLANG)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_gd32f470_ac6 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\FreeRTOS\gd32f4-ac6\inc;..\User;..\Hardware\led;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\FreeRTOS\gd32f4-ac6\port;..\Firmware\CMSIS\GD\GD32F4xx\Source\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: gd32f4xx_it.c main.c systick.c
  group hardware
    ../Hardware/led/: bsp_led.c
  group fireware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group cmsis
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group FreeRTOS
    ../FreeRTOS/gd32f4-ac6/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\port
    ../FreeRTOS/gd32f4-ac6/port/: port.c FreeRTOSConfig.h heap_4.c portmacro.h

# Keil uVision project gd32f470vg_littlefs.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f470vg_littlefs
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Hardware\inc;..\Hardware\w25qxx;..\Middle\littlefs-2.9.3;..\Middle\littlefs-port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c system_gd32f4xx.c startup_gd32f450_470.s
  group Hardware
    ../Hardware/src/: delay.c led.c
    ../Hardware/w25qxx/: spi.c w25qxx.c
  group Middle
    ../Middle/littlefs-2.9.3/: lfs.c lfs_util.c
    ../Middle/littlefs-port/: lfs_port.c
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:FMC 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
